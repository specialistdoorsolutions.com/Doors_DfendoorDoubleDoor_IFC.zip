Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-01-24T13:07:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Jan 24 13:07:41 2023* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\90e04317-eb41-43b6-9561-8e8934ec674e\fac4f044-e23d-444e-b1bc-c0983ebfad29\ifc* Database version: 5507* Database creation date: Tue Jan 24 13:07:41 2023* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Jan 24 13:07:41 2023* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Jan 24 13:07:41 2023* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDoor: NBS_SpecialistDoorSolutions_CompDrsts_DFendor_DoubleLeafDoor_VPA13:SingleSwing, NBS_SpecialistDoorSolutions_CompDrsts_DFendor_DoubleLeafDoor_VPA13:SingleSwing:637731
In: Level 0
Type - OperationType: DOUBLE_DOOR_SINGLE_SWING; ConstructionType: WOOD; ParameterTakesPrecedence: no; Sizeable: no; Material: NBS_SpecialistDoorSolutions_TexturedFinish_LupinLRV23, NBS_SpecialistDoorSolutions_StainlessSteel, NBS_Glass_Single, NBS_ClearanceZone
Type - NBS_SpecialistDoorSolutions_CompDrsts_DFendor_DoubleLeafDoor_VPA13:SingleSwing:637731:1 - PanelOperation: SWINGING
Type - BOS_General - Author: NBS; BIMObjectName: NBS_SpecialistDoorSolutions_CompositeDoorsets_DfendoorDoubleDoor_VPA13_SingleSwing; ManufacturerName: Specialist Door Solutions; ManufacturerURL: specialistdoorsolutions.com; NBSCertification: www.nationalbimlibrary.com/cert/dkgf13ex; ProductInformation: https://specialistdoorsolutions.com/products/doorsets/sds-dfendoor/; Uniclass2015Title: Composite doorsets; Uniclass2015Code: Pr_30_59_24_16; Uniclass2015Version: Products v1.22; Version: 1
Type - NBS_Data - AcousticPerformance: 0 - 20 dB, 21 - 32 dB, 33 - 35 dB, 35 - 40 dB; ArchitravesColour: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; ArchitravesFinish: PVC; ArchitravesMaterial: Medium density fibreboard, PVC; BeadingType: PVC Bead, Flush; ColourExternal: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; ColourInternal: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; Configuration: Double-leaf, single-action, Double-leaf, double-action; ContainsRedListMaterials: Yes; CountryOfProductManufacture: United Kingdom; DoorAccessories: Lock profile options, Intumescent jackets, Fire signage, Door closers, EMHO door closers, Hinges, Kickplates, Edge protectors, Fire and smoke seals, Threshold seals, Door handings, Overhead panels, Sidescreen panels, Air transfer grilles; DoorLeafCore: Timber particulate board; DoorLeafFacingsExternal: PVC; DoorLeafFacingsInternal: PVC; DoorLeafThickness: 48 mm, 58 mm; DoorsetSize: 3000 x 1180 mm, 2360 x 1180 mm, 2360 x 1104 mm, 2360 x 1129 mm, 2932 x 1075 mm, 2982 x 1075 mm, 2519 x 1028 mm, 2569 x 1028 mm, Bespoke; Edges: Postformed; FormaldehydeEmissions: To BS EN 13986, E1; FrameColour: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; FrameFilmThicknessMinimum: 1.5 - 2 mm; FrameFinish: PVC; FrameMaterials: Hardwood, Softwood; FramePerimeterSealsOrInserts: Intumescent seal, Intumescent brush; FrameThreshold: Up to 10 mm; FrameTypeOptions: Traditional frame, Split frame; GlazingType: Clearglaze, Frostglaze; HandleType: Pull handle and push plate, Cylinder pull, Digi lock; IntruderResistanceApplication: Hinge side only; Ironmongery: Define range - Stainless steel, Define plus range - Anti-microbial, Define copper range - Copper nickel; PerformanceFireResistanceIntegrity: NFR, FD30, FD30s, FD60, FD60s; ReactionToFire: NFR, FD30, FD30s, FD60, FD60s; Standard: To BS 476 Part 22:1987 BS EN 1634-1; StrengthAndDurability: Severe Duty; ThirdPartyCertification: ISO 9001:2015 ISO 114001:2015 FSC, BM Trada Q-Mark; VisionPanel: VPA13
Type - IFC - IfcExportAs: IfcDoorType; IfcExportType: DOOR
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_24_16:Composite doorsets; CodePerformance: n/a; Color: Blue, White, Red, Brown, Purple, Orange, Yellow, Green, Grey, Beige, Black, Cream, Pink; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: PVC; Grade: n/a; Manufacturer: Russell@specialistdoorsolutions.com; Material: Wood, Glass, Steel, PVC; ModelNumber: n/a; ModelReference: VPA13_SingleSwing; Name: CompositeDoorsets_DfendoorDoubleDoor_VPA13_SingleSwing_SpecialistDoorSolutions; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Five year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 2124 mm; OverallWidth: 1648 mm; Material: NBS_Glass_Single, NBS_SpecialistDoorSolutions_TexturedFinish_LupinLRV23, NBS_SpecialistDoorSolutions_StainlessSteel
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
